# Keil uVision project LiteOS_AT.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LiteOS_AT
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER1,STM32F103xE1
  c include: ..\CORE;..\STM32F1xx_HAL_Driver\Inc;..\LiteOS\cmsis;..\LiteOS\cmsis\1.0;..\LiteOS\cmsis\2.0;..\LiteOS\kernel\include;..\LiteOS\kernel\base\include;..\LiteOS\kernel\extended\include;..\LiteOS\arch\arm\arm-m\include;..\LiteOS\arch\arm\arm-m\cortex-m3;..\LiteOS\OS_CONFIG;..\User\los_config;..\User\bsp;..\User\button_drive;..\User;..\AT\at_device;..\AT\at_frame;..\AT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group core
    ../CORE/: cmsis_armcc.h core_cm3.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f103xe.s
  group driver
    ../STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_msp_template.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_usb.c
  group liteos/cmsis
    ../LiteOS/cmsis/: cmsis_liteos.c
  group liteos/kernel
    ../LiteOS/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../LiteOS/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../LiteOS/kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../LiteOS/kernel/base/mem/common/: los_memcheck.c los_memstat.c los_slab.c los_slabmem.c
    ../LiteOS/kernel/base/mem/membox/: los_membox.c
    ../LiteOS/kernel/base/misc/: los_misc.c
    ../LiteOS/kernel/base/om/: los_err.c
    ../LiteOS/kernel/: los_init.c
    ../LiteOS/kernel/extended/tickless/: los_tickless.c
  group liteos/arch
    ../LiteOS/arch/arm/arm-m/cortex-m3/keil/: los_dispatch_keil.S
    ../LiteOS/arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
  group liteos/config
    ../LiteOS/OS_CONFIG/: los_builddef.h los_printf.h target_config.h
  group at
    ../AT/at_hal/: at_hal.c
    ../AT/at_device/: esp8266.c
    ../AT/at_frame/: at_api.c at_main.c
  group user
    ../User/: main.c stm32f10x_it.c system_stm32f1xx.c board.c button_task.c esp8266_task.c
    ../User/bsp/usart/: bsp_usart.c
    ../User/button_drive/: button_drive.c
    ../User/bsp/button/: bsp_button.c
    ../User/bsp/led/: bsp_led.c
